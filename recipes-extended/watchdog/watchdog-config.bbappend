# -*- mode: Conf; -*-
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

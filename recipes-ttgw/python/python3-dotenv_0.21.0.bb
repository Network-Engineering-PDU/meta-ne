HOMEPAGE = "https://github.com/pedroburon/dotenv"
SUMMARY = "Python Dot Env Handler"
DESCRIPTION = "Shell Command and Library to write and read .env like files."
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=55ee2c3471d386636a719c8ccac40b31"

PYPI_PACKAGE = "python-dotenv"

SRC_URI[sha256sum] = "b77d08274639e3d34145dfa6c7008e66df0f04b7be7a75fd0d5292c191d79045"

inherit pypi setuptools3

